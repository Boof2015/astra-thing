BANDAID_PACKAGES:append = " astra-thing-app"
